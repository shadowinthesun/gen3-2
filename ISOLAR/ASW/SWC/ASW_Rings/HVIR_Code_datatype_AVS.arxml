<?xml version="1.0" encoding="utf-8"?>
<AUTOSAR xmlns="http://autosar.org/schema/r4.0" xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance" xsi:schemaLocation="http://autosar.org/schema/r4.0 AUTOSAR_4-0-3.xsd">
  <AR-PACKAGES>
    <AR-PACKAGE>
      <SHORT-NAME>HVIR_Code_datatype_AVS_pkg</SHORT-NAME>
      <ELEMENTS />
    </AR-PACKAGE>
  </AR-PACKAGES>
</AUTOSAR>